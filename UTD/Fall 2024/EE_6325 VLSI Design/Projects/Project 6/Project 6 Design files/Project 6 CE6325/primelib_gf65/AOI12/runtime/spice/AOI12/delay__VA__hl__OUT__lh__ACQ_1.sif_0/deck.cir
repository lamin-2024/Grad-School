.title delay__VA__hl__OUT__lh__ACQ_1

* state: !VB&!VC
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx03a.utdallas.edu, User Name: dal852207, PID: 32539
* Directory: /var/tmp/primelib.engnx03a.871870.32539/AOI12/delay__VA__hl__OUT__lh__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 0

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option  post=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage
.option measout=1 putmeas=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_vb = 0
.param __param_vc = 0
.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 6.4125e-08
.param default_slew = 1.5e-11
.param energy_change_abs_threshold = 1e-12
.param energy_change_threshold = 0.05
.param initial_delay = 1e-11
.param load_out = 1e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param pp = 3.135e-08
.param slew_va = 1e-11
.param temperature_tag = 0
.param units = 6.4125e-08
.param end_time = 9.50006e-08
.data arc_data
+ slew_va load_out temperature_tag __param_vdd __param_vss
+ 1e-11 1e-14 0 1.2 0
+ 1e-11 1.3693981e-14 0 1.2 0
+ 1e-11 2.6660665e-14 0 1.2 0
+ 1e-11 5.1422412e-14 0 1.2 0
+ 1e-11 9e-14 0 1.2 0
+ 2.7273437e-10 1e-14 0 1.2 0
+ 2.7273437e-10 1.3693981e-14 0 1.2 0
+ 2.7273437e-10 2.6660665e-14 0 1.2 0
+ 2.7273437e-10 5.1422412e-14 0 1.2 0
+ 2.7273437e-10 9e-14 0 1.2 0
+ 1.1949898e-09 1e-14 0 1.2 0
+ 1.1949898e-09 1.3693981e-14 0 1.2 0
+ 1.1949898e-09 2.6660665e-14 0 1.2 0
+ 1.1949898e-09 5.1422412e-14 0 1.2 0
+ 1.1949898e-09 9e-14 0 1.2 0
+ 2.956169e-09 1e-14 0 1.2 0
+ 2.956169e-09 1.3693981e-14 0 1.2 0
+ 2.956169e-09 2.6660665e-14 0 1.2 0
+ 2.956169e-09 5.1422412e-14 0 1.2 0
+ 2.956169e-09 9e-14 0 1.2 0
+ 5.7e-09 1e-14 0 1.2 0
+ 5.7e-09 1.3693981e-14 0 1.2 0
+ 5.7e-09 2.6660665e-14 0 1.2 0
+ 5.7e-09 5.1422412e-14 0 1.2 0
+ 5.7e-09 9e-14 0 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/eng/d/dal852207/cad/gf65/primelib_gf65/AOI12/netlists/AOI12.pex.sp'
xaoi12_inst vss out vdd c b a AOI12
va_meter a a_harness dc 0
vb_meter b b_harness dc 0
vc_meter c c_harness dc 0
vout_meter out out_harness dc 0
vvb_stim vb 0 dc 0
vvc_stim vc 0 dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_out out_harness ground_out 'load_out'
ccap_vdd vdd_harness ground_vdd 4e-14
ccap_vss vss_harness ground_vss 4e-14
vcap_ground_out ground_out 0 dc 0
vcap_ground_vdd ground_vdd 0 dc 0
vcap_ground_vss ground_vss 0 dc 0
vva_stim va 0 pwl
+  0  1.2
+  1e-11  1.2
+  '1e-11 + slew_va * 1.25'  0
+  3.136e-08  0
* **************************
* Measurements
* **************************

.meas tran cin__va__hl_trig when v(va)=1.14 cross=1 td=1e-11
.meas tran cin__va__hl_targ when v(va)=0.06 cross=1 td=1e-11
